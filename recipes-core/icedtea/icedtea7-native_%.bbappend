
EXTRA_OEMAKE += ' \
                OE_CFLAGS="${CFLAGS} -w" \
                OE_CPPFLAGS="${CPPFLAGS} -w" \
                OE_CXXFLAGS="${CXXFLAGS} -w" \
               '

